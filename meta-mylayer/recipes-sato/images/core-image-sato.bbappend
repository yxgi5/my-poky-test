#IMAGE_INSTALL_append = " helloworld"
IMAGE_INSTALL:append = " helloworld"

